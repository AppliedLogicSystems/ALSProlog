/*================================================================
          macos3.c
          --Generated from: macos.src
          Date: 96/9/26   Time: 15:40:3
		--by ALS Interface Generator

 *===============================================================*/

#include "alspi.h"
#include "cinterf.h"
#include "macos.h"


static int macos_gv_dispatch(void)
{
	PWord dispatchVal; int dispatchType;
	PWord argVal; int argType;
	PWord retVal; int retType;

	PI_getan(&dispatchVal,&dispatchType,1);
	PI_getan(&argVal,&argType,2);

	if (dispatchType != PI_INT)  PI_FAIL;

	switch( dispatchVal )
	{
		case 0:
		PI_makedouble(&retVal,&retType,(double) (long) &qd);
		break;
		default:
			PI_FAIL;
	}

if (!PI_unify(argVal,argType,retVal,retType))
		PI_FAIL;

	PI_SUCCEED;
}

PI_BEGIN
	PI_PDEFINE("macos_gv",2,macos_gv_dispatch,"_macos_gv_dispatch")
PI_END

void macos4_init(void)
{
	PI_INIT;
}

extern void macos_compact_init(void);
extern void macos2_init(void);
extern void macos3_init(void);
void macos_init(void)
{
	macos_compact_init();
	macos2_init();
	macos3_init();
	macos4_init();

}
